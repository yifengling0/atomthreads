# IAR project atomthreads-sample-iar.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x40
  General.GenHeapSize: 0x20
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; stm8s-periphs; ..\..\kernel; ..\..\extra; ..\..\drv; ..\..\tests; ..\..\com; ..\..\lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: atomthreads-sample-iar.srec
  ILINK.IlinkOutputFile: atomthreads.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG; STM8S105
  group com/console
    ../../com/console/: console.c console.h
  group com/debug
    ../../com/debug/: debug.c debug.h debug_port.h
  group drv
    ../../drv/: iosdrv.c iosdrv.h sio.h
  group drv/sio
    ../../drv/sio/: sio.c
  group extra
    ../../extra/: event.c
  group kernel
    ../../kernel/: atom.h atomkernel.c atommutex.c atommutex.h atomqueue.c atomqueue.h atomsem.c atomsem.h atomtimer.c atomtimer.h
  group lib
    ../../lib/: mem.h numberical.c numberical.h queue.h
  group lib/alloc
    ../../lib/alloc/: allocator.c allocator.h
  group lib/buffer
    ../../lib/buffer/: ringbuffer.c ringbuffer.h
  group stm8
    ./: atomport-asm-iar.s atomport-private.h atomport-tests.h atomport.c atomport.h stm8s_conf.h uart.c uart.h
  group stm8s-periphs
    stm8s-periphs/: stm8s.h stm8s_clk.c stm8s_clk.h stm8s_gpio.c stm8s_gpio.h stm8s_itc.c stm8s_itc.h stm8s_tim1.c stm8s_tim1.h stm8s_type.h stm8s_uart1.c stm8s_uart1.h
  group tests
    ../../tests/: atomtests.h main.c
